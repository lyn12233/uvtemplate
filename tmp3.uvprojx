# Keil uVision project tmp3.uvprojx, settings and files
target tmp3 (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: tmp3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,A=0,_WIZCHIP_=5500,_LOOPBACK_DEBUG_
  c include: ./Core/Inc;./Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;./Drivers/STM32F1xx_HAL_Driver/Inc;./Drivers/CMSIS/Device/ST/STM32F1xx/Include;./Drivers/CMSIS/Include;.\FreeRTOS\include;.\FreeRTOS\port;.\User;.\Task;.\StdPort;.\IOLibrary\Ethernet;.\IOLibrary\Application\loopback;.\IOLibrary\Application\multicast;.\IOLibrary\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./Core/Src/: startup_stm32f103xe.s
  group main
    ./Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c freertos_hooks.c
  group hal
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group cmsis
    ./Core/Src/: system_stm32f1xx.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/port/: port.c
  group iolibrary
    ./IOLibrary/Application/loopback/: loopback.c
    ./IOLibrary/Application/multicast/: multicast.c
    ./IOLibrary/Ethernet/W5500/: w5500.c
    ./IOLibrary/Ethernet/: socket.c wizchip_conf.c
  group user
    ./User/: user_main.c
    ./User/user_init/: init_adc.c init_led.c init_usart1.c user_init.c
    ./User/wiz/: wiz_test.c wizspi_init.c
    ./User/types/: vo.c
    ./User/esp/: parser.c exec.c espsock.c
  group task
    ./Task/: blink_task.c
  group std_port
    ./StdPort/: log.c port_errno.c port_fd.c port_socket.c
